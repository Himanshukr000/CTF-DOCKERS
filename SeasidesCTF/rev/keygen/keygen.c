#include<stdio.h>
#include<string.h>
#include<unistd.h>

void assign(char *a,char *b, char *c);
int lencheck(char inp[]);
int func1(char inp[],int arr1[], int arr2[]);
int func2(char inp[],int arr1[], int arr2[]);
void flag(char inp[]);

int main()
{
	int a[256] = {105,81,198,74,115,41,255,186,236,242,205,227,171,124,251,84,70,27,194,231,248,118,232,46,141,51,90,201,99,102,159,13,154,49,50,163,183,93,88,23,37,94,5,178,233,180,212,14,155,116,17,33,130,220,65,112,61,161,135,252,62,126,225,234,1,150,151,56,107,42,143,59,92,60,176,219,175,26,24,67,2,170,254,209,250,148,58,216,230,97,117,249,190,168,137,15,187,177,153,241,149,239,235,0,179,202,247,203,229,72,11,100,208,31,71,30,189,123,35,20,28,121,197,158,75,172,36,80,9,111,16,25,21,245,34,164,125,181,127,152,19,77,78,188,224,119,52,134,95,85,108,4,43,54,162,240,211,79,226,253,228,8,73,10,169,68,138,243,213,76,91,45,142,6,215,132,66,222,196,246,173,133,48,244,32,195,7,160,185,218,21748,120,87,106,207,144,210,238,101,96,98,53,165,63,140,128,192,89,47,12,22,131,184,39,182,147,199,109,18,193,57,237,174,69,122,157,55,104,3,166,139,110,145,40,129,86,206,114,191,113,146,167,136,214,156,221,200,38,44,82,223,29,204,103,64};
	
	int b[256] = {164, 159, 204, 223, 130, 165, 29, 200, 154, 156, 225, 136, 221, 146, 214, 102, 46, 201, 145, 243, 2, 167, 161, 141, 118, 48, 232, 27, 248, 84, 194, 124, 238, 227, 251, 242, 171, 186, 205, 41, 236, 74, 255, 81, 115, 191, 198, 206, 215, 73, 114, 113, 30, 139, 40, 3, 127, 55, 166, 122, 147, 174, 157, 17, 247, 18, 237, 199, 193, 182, 109, 184, 104, 22, 39, 47, 131, 192, 12, 140, 89, 44, 128, 98, 63, 101, 53, 210, 96, 207, 70, 87, 144, 83, 106, 218, 120, 160, 217, 195, 185, 244, 7, 133, 32, 246, 231, 112, 173, 49, 196, 6, 66, 45, 105, 76, 142, 51, 91, 68, 213, 10, 138, 8, 169, 253, 129, 79, 228, 240, 226, 54, 211, 4, 162, 85, 43, 134, 108, 119, 95, 188, 52, 77, 224, 152, 78, 181, 80, 64, 110, 245, 125, 25, 34, 111, 21, 19, 16, 172, 9, 158, 36, 121, 75, 20, 197, 123, 28, 86, 35, 31, 189, 100, 71, 72, 208, 203, 11, 202, 229, 0, 69, 239, 179, 241, 235, 177, 149, 15, 153, 168, 187, 249, 137, 97, 190, 216, 117, 148, 230, 209, 58, 170, 50, 67, 254, 103, 26, 219, 24, 60, 175, 59, 176, 42, 92, 56, 143, 150, 107, 234, 151, 126, 1, 252, 38, 90, 62, 222, 135, 220, 61, 33, 65, 116, 163, 57, 14, 180, 155, 178, 212, 94, 233, 23, 5, 93, 37, 99, 88, 132, 183, 13, 82, 250};


	int i,j;
	int checkl;
	char array1[15],array2[15];
	char *point1,*point2,*point3,input[31];
	point1 = &input[0];
	
	printf("Input:");
	scanf("%s",input);
	point2 = &array1[0];
	point3 = &array2[0];
	checkl = lencheck(input);


	if(!checkl)
	{

	assign(point1,point2,point3);

	int answer1 = func1(array2,a,b); 
	int answer2 = func2(array1,a,b);


	if(answer1 == 15 && answer2 == 15)
	{

		flag(input);
	}

	else
	{
		printf("\nWrong Input!\n\n");
		sleep(5);
	}
	
	}

	else
	{
		printf("\n\nWrong Length!\n\n")	;
		sleep(5);
	}

	return 0;

}


void assign(char *a,char *b, char *c)
{
	int j = 0;
	int k = 0;
	for(int i = 0; *(a+i)!= '\0'; i++)
	{
		if(i%2 == 0)
		{
			*(b + j) = *(a + i);
			j++;
		}

		else
		{
			*(c + k) = *(a + i);
			k++;			
		}
	}	
}


int lencheck(char inp[])
{
	
	int ret = 1;

	int i = strlen(inp);
	
	i = (i * 18);
	int mod = i % 27;
	int div = i / 27;

	if((mod == 0) && (div == 20))
		ret = 0; 
	return ret;
}




int func1(char inp[],int arr1[], int arr2[])
{
	char check[15] = {'q', 'N', 'V', 'P', 'P', 'E', 'P', 'Z', 'P', 'E', 'c', 'R', 'P', 'h', 'i'};
	int ret = 0;
	char temp;
	printf("\n");
	int i = 0;
	int j = 0;
	while(i<15)
	{
		j = 0;
		while(j<256)
		{	
			temp = arr1[j];
			
			if(inp[i] == temp)
			{
				
				temp = arr2[j];

				if(temp == check[i])
				{
					ret = ret+1;
				}

			}

			j++;
			
		}

		i++;

	}
	

	return ret;

}

int func2(char inp[],int arr1[], int arr2[])
{
	char check[15] = {'.', '4', 'n', 'g', 'F', 'i', 'I', 'f', '0', 'R', '9', '0', 'f', '.', 'N'};
	int ret = 0;
	char temp;
	printf("\n");
	int i = 0;
	int j = 0;
	while(i<15)
	{
		j = 0;
		while(j<256)
		{	
			temp = arr1[j];

			if(inp[i] == temp)
			{
				
				temp = arr2[j];
				
				if(temp == check[i])
				{
					ret = ret+1;
				}
			}

			j++;
			
		}

		i++;

	}

	return ret;

}

void flag(char inp[])
{
	printf("Congratulations!\n\nFlag:	seasides{");
	
	for(int i = 0; i<30; i++)
	{
		printf("%c", inp[i]);
	}
	printf("}\n\n");

	sleep(10);

}
